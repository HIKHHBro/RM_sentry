# Keil uVision project F427HIIxRMOLD.uvprojx, settings and files
target F427HIIxRMOLD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F427HIIxRMOLD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\User\app\inc;..\User\bsp\inc;..\User\drivers\counters\inc;..\User\drivers\data_structure\inc;..\User\drivers\modules\inc;..\User\task\inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c freertos.c main.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c queue.c tasks.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group user/bsp
    ../User/bsp/src/: baseclass.c bsp_can.c bsp_usart.c
    ../User/bsp/inc/: baseclass.h bsp_can.h bsp_usart.h userdriverconfig.h userFreeRTOSConfig.h
  group user/drivers
    ../User/drivers/counters/inc/: counters.h motion_model.h power_buffer_pool.h
    ../User/drivers/counters/src/: counters.c motion_model.c power_buffer_pool.c
    ../User/drivers/data_structure/inc/: DataStructure.h
    ../User/drivers/data_structure/src/: DataStructure.c
    ../User/drivers/modules/inc/: bluetooth.h DJI_dbus.h enconder.h leds_tip.h motor.h ultrasonic.h usart_debug.h wholepositioning.h pc_data.h communicate.h currentmeter.h gyro.h
    ../User/drivers/modules/src/: bluetooth.c DJI_dbus.c enconder.c laser_ranging.c leds_tip.c motor.c ultrasonic.c usart_debug.c wholepositioning.c pc_data.c communicate.c currentmeter.c gyro.c
  group user/app
    ../User/app/inc/: chassis.h gimbal.h parse.h rammer.h send_message.h sys_detect.h user_tx.h sys_selfchecking.h
    ../User/app/src/: chassis.c gimbal.c parse.c send_message.c rammer.c sys_detect.c user_tx.c sys_selfchecking.c
  group user/task
    ../User/task/inc/: debug_by_keil.h laser_ranging.h sys_task.h user.h
    ../User/task/src/: debug_by_keil.c sys_task.c user.c
software components: CMSIS:CORE 4.3.0
